# Keil uVision project Xnode.uvproj, settings and files
target Internal Flash (ARM-ADS)
  device: LPC4357 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Xnode
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M4 ARM_MATH_CM4 __FPU_PRESENT=1 USB xGATEWAY xSNOOZEALARM PRINTDATA FRA  _UART1 INACT xGW_SENSE xSTRAIN xKHZ
  c include: ..\app;..\lib\drivers;..\lib\drivers\ads131e08;..\lib\drivers\adxl362;..\lib\drivers\at86rf233;..\lib\drivers\k9f1g08u0a;..\lib\fatfs;..\lib\freertos;..\lib\lpc43xx;..\lib\lz4;..\lib\radio;..\lib\system;..\lib\time64;..\lib\timesync;..\lib\usb;..\lib\yaffs2;..\lib\paho
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x22000
  memory RVCT10: RAM 0x20000000 size 0x22000
  group App
    ../app/: app.c app_gateway.c app_indicator.c app_sensor.c AutoMonitor.c RemoteSensing.c RetrieveData.c Settings.c
  group CMSIS
    ../lib/cmsis/: arm_cortexM4lf_math.lib
  group Drivers
    ../lib/drivers/ads131e08/: ads131.c
    ../lib/drivers/adxl362/: adxl362.c
    ../lib/drivers/: fs_sdio.c led.c pmic.c rtc.c spi.c vcom.c poti2c.c switch.c
    ../lib/drivers/k9f1g08u0a/: nandflash_k9f1g08u0a.c
    ../lib/drivers/at86rf233/: rf233.c rf233-arch.c trx_access.c
  group FatFS
    ../lib/fatfs/option/: ccsbcs.c syscall.c
    ../lib/fatfs/: ff.c
  group FreeRTOS
    ../lib/freertos/: event_groups.c heap_3.c list.c port.c queue.c tasks.c timers.c
  group LPC43xx
    ../lib/lpc43xx/: debug_frmwrk.c lpc43xx_atimer.c lpc43xx_cgu.c lpc43xx_evrt.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_pwr.c lpc43xx_rit.c lpc43xx_rtc.c lpc43xx_scu.c lpc43xx_sdif.c lpc43xx_sdmmc.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_wwdt.c system_LPC43xx.c startup_LPC43xx.s lpc43xx_uart.c
  group LZ4
    ../lib/lz4/: lz4.c
  group Radio
    ../lib/radio/: Radio.c GenericComm.c ReliableComm.c RemoteCommand.c SendLData.c SendSMsg.c
  group System
    ../lib/system/: filter.c filter_o.c NodeReset.c ResampleUSF.c sdcard.c sdmalloc.c Sensing.c SnoozeAlarm.c TriggerSensing.c xnode.c Utils.c 4gFTP.c
  group Time64
    ../lib/Time64/: GlobalTime.c LocalTime.c SysTime.c
  group TimeSync
    ../lib/timesync/: timesync.c
  group USB
    ../lib/USB/: cdcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group Yaffs2
    ../lib/Yaffs2/: nanddrv.c yaffs_allocator.c yaffs_attribs.c yaffs_bitmap.c yaffs_checkptrw.c yaffs_ecc.c yaffs_endian.c yaffs_error.c yaffs_guts.c yaffs_hweight.c yaffs_nameval.c yaffs_nand.c yaffs_nand_drv.c yaffs_osglue.c yaffs_packedtags1.c yaffs_packedtags2.c yaffs_qsort.c yaffs_summary.c yaffs_tagscompat.c yaffs_tagsmarshall.c yaffs_verify.c yaffs_yaffs1.c yaffs_yaffs2.c yaffscfg2k.c yaffsfs.c
  group paho
    ../lib/paho/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
